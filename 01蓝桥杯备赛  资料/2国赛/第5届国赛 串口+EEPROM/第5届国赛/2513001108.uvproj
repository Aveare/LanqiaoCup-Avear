# Keil uVision project 2513001108.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2513001108 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c ds1302.c iic.c onewire.c Uart.c Uart.h
