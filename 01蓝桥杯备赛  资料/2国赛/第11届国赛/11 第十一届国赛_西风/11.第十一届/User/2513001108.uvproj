# Keil uVision project 2513001108.uvproj, settings and files
target 2513001108 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Xifeng +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: iic.c init.c key.c led.c seg.c ds1302.c onewire.c
