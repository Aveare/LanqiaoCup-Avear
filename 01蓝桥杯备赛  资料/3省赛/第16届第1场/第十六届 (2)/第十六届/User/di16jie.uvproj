# Keil uVision project di16jie.uvproj, settings and files
target di16jie (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: di16jie +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group Driver
    ../Driver/: Ds18B20.c IIC.c Init.c Key.c Led.c Seg.c Ut_Wave.c Ut_Wave.h
  group User
    ./: main.c
