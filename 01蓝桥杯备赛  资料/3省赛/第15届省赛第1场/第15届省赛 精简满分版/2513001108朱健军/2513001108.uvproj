# Keil uVision project 2513001108.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2513001108 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver
  group User
    ./: main.c
  group Driver
    ./Driver/: ds1302.c iic.c onewire.c Key.c Led.c Seg.c Init.c
