# Keil uVision project 11.7.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 11.7 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: text.c
