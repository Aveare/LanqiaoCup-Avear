# Keil uVision project 122.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 122 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1222222.c
