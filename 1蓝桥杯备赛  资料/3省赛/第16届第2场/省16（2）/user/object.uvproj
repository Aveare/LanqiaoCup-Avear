# Keil uVision project object.uvproj, settings and files
target 52rjn (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: object +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\obj
  group user
    ./: main.c
  group obj
    ../obj/: sys.c sys.h display.c display.h key.c key.h timer.c timer.h ds1302.c ds1302.h iic.c iic.h onewire.c onewire.h chaoshen.c chaoshen.h
