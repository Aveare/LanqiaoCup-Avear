# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver
  group Source Group 1
    ./Driver/: main.c device.c timer.c smg.c kbt.c uart.c onewire.c sonic.c ds1302.c iic.c ne555.c
