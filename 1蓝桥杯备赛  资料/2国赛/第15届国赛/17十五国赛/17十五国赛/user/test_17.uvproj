# Keil uVision project test_17.uvproj, settings and files
target test_17 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test_17 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\driver
  group user
    ./: main.c
  group driver
    ../driver/: init.c init.h seg.c seg.h led.c led.h uart.c uart.h key.c key.h csb.c csb.h iic.c iic.h
