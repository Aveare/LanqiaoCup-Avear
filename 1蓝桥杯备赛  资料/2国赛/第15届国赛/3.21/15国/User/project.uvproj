# Keil uVision project project.uvproj, settings and files
target project (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: iic.c Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h Uart.c Uart.h Wave.c Wave.h
