# Keil uVision project Xifeng.uvproj, settings and files
target Xifeng (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Xifeng +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: init.c key.c led.c seg.c onewire.c iic.c ds1302.c uart.c
