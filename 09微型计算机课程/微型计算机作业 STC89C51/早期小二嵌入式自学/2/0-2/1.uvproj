# Keil uVision project 1.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./Listings/: main.c
  group Driver
    ./Listings/: key.c key.h seg.c seg.h
