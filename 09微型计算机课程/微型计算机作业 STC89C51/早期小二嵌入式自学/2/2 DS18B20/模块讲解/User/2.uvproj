# Keil uVision project 2.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./Objects/: main.c
  group Driver
    ../Driver/: Init.c Init.h Key.c Key.h Led.c Led.h onewire.c onewire.h Seg.c Seg.h
