# Keil uVision project 18B20.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
  group Driver
    ./: Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h onewire.c onewire.h
