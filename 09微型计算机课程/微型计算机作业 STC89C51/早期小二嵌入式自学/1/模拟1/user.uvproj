# Keil uVision project user.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: user +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c
  group Driver
    ./: key.c seg.c
