# Keil uVision project 11.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 11 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Listings
  group Source Group 1
    ./: main.c
    ./Listings/: Key.c Key.h
